# Keil uVision project leds.uvprojx, settings and files
target Leds (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F207VGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TestProject +hex
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Lib\CMSIS\inc;.\main\inc;.\Lib\StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group startup
    ./startup/: startup_stm32f207xx.s
  group CMSIS
    ./Lib/CMSIS/: system_stm32f2xx.c
  group main
    ./main/src/: main.c tim.c leds.c sysclock.c
  group StdPeriph_Driver
    ./Lib/StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_flash.c stm32f4xx_tim.c stm32f4xx_gpio.c
